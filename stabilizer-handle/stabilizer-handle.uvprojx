# Keil uVision project stabilizer-handle.uvprojx, settings and files
target stabilizer-handle-v1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stabilizer-handle-v1
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR LAB6
  c include: ..;..\..\..;.
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --symdefs Lab6.def
  group Source
    ./: startup.s main.c
    ../inc/: LaunchPad.c PLL.c WTimer0A.c WTimer1A.c I2C0.c PWM.c
    ../RTOS_Labs_common/: OS.c ST7735.c UART0int.c osasm.s mpu6050.h mpu6050.c digitalServo.c digitalServo.h heap.c eDisk.c
software components: CMSIS:CORE 5.0.2
